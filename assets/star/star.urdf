Commit message: update: urdf files

File: assets/star/star.urdf (robot description, URDF)
Before this commit: robot star, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=meshes/star.stl scale=0.035 0.035 0.035; visual mesh filename=meshes/star.stl scale=0.035 0.035 0.035
