Commit message: fix: add mimic of slider 38 with slider 37 in simplified urdf

File: assets/Hiwonder_urdf_simplified/Hiwonder.urdf (robot description, URDF)
Before this commit: robot Hiwonder, 10 links, 9 joints
Joints:
- joint Slider 38: mimic (none) -> joint=Slider 37 multiplier=-1.0 offset=0.0
